# Keil uVision project V6-git.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: V6-git +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_FULL_LL_DRIVER
  c include: ..\User\bsp\inc;..\User\bsp;..\User;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\Libraries\STM32F4xx_HAL_Driver\Src\Legacy;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\freeRTOS;..\freeRTOS\include;..\freeRTOS\portable\RVDS\ARM_CM4_MPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c
    ../User/bsp/: stm32f4xx_it.c
  group BSP
    ../User/bsp/: bsp.c bsp_msg.c
    ../User/bsp/src/: bsp_fmc_io.c bsp_key.c bsp_led.c bsp_timer.c bsp_uart_fifo.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group SEGGER/HardFault
    ../User/segger/HardFaultHandlerMDK/: SEGGER_HardFaultHandler.c HardFaultHandler.S
  group FreeRTOS/Source
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Ports
    ../freeRTOS/portable/MemMang/: heap_4.c
    ../freeRTOS/portable/RVDS/ARM_CM4F/: port.c
